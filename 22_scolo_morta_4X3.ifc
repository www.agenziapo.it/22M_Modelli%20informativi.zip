Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: 22_scolo_morta_X3_Rev01.ifc
Time: 2025-04-22T17:15:19+02:00
Written by: IfcOpenShell 0.8.3-alpha250421
Made in: Bonsai 0.8.3-alpha250421-5c4f157

# IfcBuildingElementProxy, Terreno
In: Deviazione scolo Morta
Description: Created by Civil Site Design
