Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: 22_stato_di_fatto_4X3.ifc
Time: 2025-04-18T15:08:12+02:00
Written by: IfcOpenShell 0.8.2-alpha250212
Made in: Bonsai 0.8.2-alpha250212-f24de9d

# IfcBuildingElementProxy, Terreno
In: Terreno
Description: Created by Civil Site Design
