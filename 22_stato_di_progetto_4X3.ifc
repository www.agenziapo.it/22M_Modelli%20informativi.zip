Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: 22_stato_di_progetto_4X3.ifc
Time: 2025-04-22T17:26:28+02:00
Written by: IfcOpenShell 0.8.3-alpha250421
Made in: Bonsai 0.8.3-alpha250421-5c4f157

# IfcBuildingElementProxy (33)
Name | In | String Name | Code 1 | Code 2 | Layer Index | Material
Burghe | Piede pennello | asse_piede_pennello | R2 | R3 | 2 | PP - Burghe
Pietrame 300-1000 kg | Piede pennello | asse_piede_pennello | R1 | R2 | 3 | PP - Pietrame 300-10000 kg
Tappeti zavorrati | Piede pennello | asse_piede_pennello | R2 | R3 | 1 | PP - Tappeti zavorrati
22_Canale secondario/RAR/RBAT/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale secondario | RAR | RBAT | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
2 x 22_Canale principale/RAR/RBAT/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale principale | RAR | RBAT | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
Tout Venant | Strada | 22_pennello | C.L. | RST | 1 | ST - Tout Venant
Misto stabilizzato | Strada | 22_pennello | C.L. | RST | 2 | ST - Misto stabilizzato
2 x 22_Canale principale/C.L./LAR/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale principale | C.L. | LAR | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | C.L. | RST | 3 | CP - Pietrame 300-1000 kg
Tout Venant | Strada | 22_pennello | C.L. | LST | 1 | ST - Tout Venant
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | LAB | LAD | 1 | TA - Pietrame 300-1000 kg
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | RST | RAT | 1 | CP - Pietrame 300-1000 kg
Tappeti zavorrati | Piede pennello | asse_piede_pennello | R1 | R2 | 1 | PP - Tappeti zavorrati
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | RAT | RAFS | 1 | CP - Pietrame 300-1000 kg
22_Canale secondario/LAR/LBAT/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale secondario | LAR | LBAT | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
22_Canale secondario/C.L./RAR/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale secondario | C.L. | RAR | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | LST | LAT | 1 | CP - Pietrame 300-1000 kg
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | RAFS | RAFR | 1 | CP - Pietrame 300-1000 kg
Pietrame 300-1000 kg | Piede pennello | asse_piede_pennello | C.L. | R1 | 2 | PP - Pietrame 300-10000 kg
Terreno | Lanca | Description: Created by Civil Site Design
2 x 22_Canale principale/LAR/LBAT/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale principale | LAR | LBAT | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | C.L. | LST | 3 | CP - Pietrame 300-1000 kg
Tappeti zavorrati | Piede pennello | asse_piede_pennello | R3 | R4 | 1 | PP - Tappeti zavorrati
Burghe | Piede pennello | asse_piede_pennello | C.L. | R1 | 1 | PP - Burghe
Burghe | Piede pennello | asse_piede_pennello | R1 | R2 | 2 | PP - Burghe
2 x 22_Canale principale/C.L./RAR/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale principale | C.L. | RAR | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
Misto stabilizzato | Strada | 22_pennello | C.L. | LST | 2 | ST - Misto stabilizzato
Pietrame 300-1000 kg | Corpo pennello | 22_pennello | LAD | LAT | 1 | CP - Pietrame 300-1000 kg
22_Canale secondario/C.L./LAR/1/CC - Pietrame 300-1000 kg | Lanca | 22_Canale secondario | C.L. | LAR | 1 | CC - Pietrame 300-10000 kg | Description: Created by Civil Site Design
